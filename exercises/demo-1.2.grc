options:
  parameters:
    author: kn0
    generate_options: qt_gui
    id: demo_1_2
    output_language: python
    title: Demo 1.2 - So Much Noise
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=Microphone,DEV=0
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [audio_source_0, '0', audio_sink_0, '0']
- [audio_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
