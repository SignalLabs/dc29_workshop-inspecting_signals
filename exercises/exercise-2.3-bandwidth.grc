options:
  parameters:
    generate_options: qt_gui
    id: exercise_2_2
    output_language: python
    title: Exercise 2.2 - Moving Fast
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ./samples/8_bps_fsk_sample.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: ./samples/1200_bps_fsk_sample.wav
    repeat: 'True'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (0,0)
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (1,0)
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_wavfile_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_1, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
